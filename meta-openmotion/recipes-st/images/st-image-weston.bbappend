IMAGE_INSTALL += "openmotion-host"
